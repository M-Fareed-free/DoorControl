# Keil uVision project door_control_ecu1_final.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: door_control_ecu1_final
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group mcal
    ./: gpio.c gpio.h timer.h timer.c
  group handlers_interfaces
    ./: door_sensor.h door_sensor.c light_switch.c light_switch.h
  group drivers
    ./: switch.h switch.c can.h can.c speed_sensor.h speed_sensor.c
  group os
    ./: os_handler.c os_handler.h
  group Application
    ./: main.c bcm.c bcm.h bcm_1.c
