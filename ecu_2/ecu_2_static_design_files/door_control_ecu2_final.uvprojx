# Keil uVision project door_control_ecu2_final.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: door_control_ecu2_final
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c door_control.c door_control.h
  group mcal
    ./: gpio.c gpio.h timer.c timer.h
  group drivers
    ./: light.h light.c buzzer.h buzzer.c can.c can.h
  group handlers_interfaces
    ./: messages_handler.h messages_handler.c output.h output.c
  group os
    ./: os_handler.c os_handler.h
